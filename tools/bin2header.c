/*
 * bin2header - turn a binary blob into a C array with a header guard.
 *
 * usage: bin2header <input.bin> <output.h> <symbol>
 *
 * The blob stays the source of truth; this only spells its bytes out as C.
 * The guard is the symbol in upper case with a trailing _H.
 */

#include <stdio.h>
#include <stdlib.h>

#define BYTES_PER_LINE 16

static void fail(const char *message)
{
    fprintf(stderr, "bin2header: %s\n", message);
    exit(EXIT_FAILURE);
}

static void print_macro_name(FILE *out, const char *symbol)
{
    unsigned int index;

    for (index = 0U; symbol[index] != '\0'; index++) {
        char letter = symbol[index];

        if (letter >= 'a' && letter <= 'z') letter = (char)(letter - 'a' + 'A');
        else if (!((letter >= 'A' && letter <= 'Z') ||
                   (letter >= '0' && letter <= '9'))) letter = '_';
        fputc(letter, out);
    }
}

int main(int argc, char **argv)
{
    const char *input_path;
    const char *output_path;
    const char *symbol;
    FILE *input;
    FILE *output;
    int byte;
    unsigned int count = 0U;
    unsigned int column = 0U;

    if (argc != 4) {
        fprintf(stderr, "usage: %s <input.bin> <output.h> <symbol>\n", argv[0]);
        return EXIT_FAILURE;
    }
    input_path = argv[1];
    output_path = argv[2];
    symbol = argv[3];

    input = fopen(input_path, "rb");
    if (!input) {
        fprintf(stderr, "bin2header: cannot open %s: ", input_path);
        perror("");
        return EXIT_FAILURE;
    }
    output = fopen(output_path, "wb");
    if (!output) {
        fprintf(stderr, "bin2header: cannot write %s: ", output_path);
        perror("");
        return EXIT_FAILURE;
    }

    fprintf(output, "/* Generated by tools/bin2header.c from %s. */\n",
            input_path);
    fprintf(output, "#ifndef ");
    print_macro_name(output, symbol);
    fprintf(output, "_H\n#define ");
    print_macro_name(output, symbol);
    fprintf(output, "_H\n\nstatic const unsigned char %s[] = {\n", symbol);

    while ((byte = fgetc(input)) != EOF) {
        fprintf(output, column == 0U ? "    " : " ");
        fprintf(output, "0x%02x,", (unsigned int)byte);
        count++;
        column++;
        if (column == BYTES_PER_LINE) {
            fprintf(output, "\n");
            column = 0U;
        }
    }
    if (column != 0U) fprintf(output, "\n");
    fprintf(output, "};\n\n#endif\n");

    if (count == 0U) fail("input is empty");
    if (ferror(input)) fail("read failed");
    if (fclose(output) != 0) fail("write failed");
    fclose(input);
    return EXIT_SUCCESS;
}
